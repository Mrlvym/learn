# Keil uVision project Fire_stm32f407.uvprojx, settings and files
target 工程模板 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp\sys;..\..\User\bsp\delay;..\..\User\bsp\usart;..\..\User\bsp\led;..\..\User\bsp\flash;..\..\User\bsp\rtc;..\..\User\bsp\key;..\..\User\hal\delay;..\..\User\hal\led;..\..\User\hal\usart;..\..\User\hal\flash;..\..\User\hal\rtc;..\..\User\hal\key;..\..\User\app\init;..\..\User\app\led;..\..\User\app\flash;..\..\User\app\rtc;..\..\User\bsp\iwwdg;..\..\User\hal\iwwdg;..\..\User\app\iwwdg;..\..\User\bsp\sdio;..\..\User\hal\sdio;..\..\User\app\sdio;..\..\User\app\fatfs;..\..\User\FATFS\src;..\..\User\app\fatfs;..\..\User\bsp\iic;..\..\User\hal\iic;..\..\User\bsp\sram;..\..\User\hal\sram;..\..\User\app\sram;..\..\User\bsp\lcd;..\..\User\hal\lcd;..\..\User\app\lcd;..\..\User\bsp\touch;..\..\User\hal\touch;..\..\User\app\touch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
  group BSP
    ../../User/bsp/sys/: sys.c
    ../../User/bsp/flash/: bsp_spi_flash.c
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/delay/: bsp_delay.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/rtc/: bsp_rtc.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/iwwdg/: bsp_iwwdg.c
    ../../User/bsp/sdio/: bsp_sdio.c
    ../../User/bsp/iic/: bsp_iic.c
    ../../User/bsp/sram/: bsp_sram.c
    ../../User/bsp/lcd/: bsp_nt35510_lcd.c
    ../../User/bsp/touch/: bsp_touch_iic.c bsp_touch_gt911.c
  group HAL
    ../../User/hal/flash/: hal_spi_flash.c
    ../../User/hal/usart/: hal_debug_usart.c
    ../../User/hal/delay/: hal_delay.c
    ../../User/hal/led/: hal_led.c
    ../../User/hal/rtc/: hal_rtc.c
    ../../User/hal/key/: hal_key.c
    ../../User/hal/iwwdg/: hal_iwwdg.c
    ../../User/hal/sdio/: hal_sdio.c
    ../../User/hal/iic/: hal_iic.c
    ../../User/hal/sram/: hal_sram.c
    ../../User/hal/lcd/: hal_nt35510_lcd.c
    ../../User/hal/touch/: hal_touch_gt911.c
  group APP
    ../../User/app/flash/: app_spi_flash.c
    ../../User/app/init/: app_init.c
    ../../User/app/led/: app_led.c
    ../../User/app/rtc/: app_rtc.c
    ../../User/app/iwwdg/: app_iwwdg.c
    ../../User/app/sdio/: app_sdio.c
    ../../User/app/fatfs/: app_fatfs.c
    ../../User/app/sram/: app_sram.c
    ../../User/app/lcd/: app_lcd_task.c app_nt35510_lcd.c
    ../../User/app/touch/: app_touch_gt911.c app_touch_task.c
  group FATFS
    ../../User/FATFS/src/: diskio.c ff.c
    ../../User/FATFS/src/option/: cc936.c
  group DOC
    ../../: 必读说明.txt
