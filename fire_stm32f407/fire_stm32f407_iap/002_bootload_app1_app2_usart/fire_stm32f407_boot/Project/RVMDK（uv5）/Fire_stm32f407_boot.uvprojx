# Keil uVision project Fire_stm32f407_boot.uvprojx, settings and files
target Fire_stm32f407_boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_stm32f407_boot +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp\sys;..\..\User\bsp\usart;..\..\User\bsp\delay;..\..\User\hal\delay;..\..\User\hal\usart;..\..\User\app\init;..\..\User\app\exit;..\..\User\bsp\led;..\..\User\hal\led;..\..\User\app\led;..\..\User\bsp\key;..\..\User\hal\key;..\..\User\app\iap;..\..\User\bsp\flash;..\..\User\hal\flash;..\..\User\bsp\iap;..\..\User\hal\iap;..\..\User\bsp\iwwdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_syscfg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
  group BSP
    ../../User/bsp/sys/: sys.c
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/delay/: bsp_delay.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/flash/: bsp_flash.c
    ../../User/bsp/iap/: bsp_iap.c
    ../../User/bsp/iwwdg/: bsp_iwwdg.c
  group HAL
    ../../User/hal/delay/: hal_delay.c
    ../../User/hal/usart/: hal_debug_usart.c
    ../../User/hal/led/: hal_led.c
    ../../User/hal/key/: hal_key.c
    ../../User/hal/flash/: hal_flash.c
    ../../User/hal/iap/: hal_iap.c
  group APP
    ../../User/app/init/: app_init.c
    ../../User/app/led/: app_led.c
    ../../User/app/exit/: app_exit.c
    ../../User/app/iap/: app_iap.c
  group DOC
    ../../: 必读说明.txt
