# Keil uVision project Fire_FreeRTOS_F407_App.uvprojx, settings and files
target Fire_FreeRTOS_F407_App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS_F407_App +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\Bsp\sys;..\..\User\Bsp\usart;..\..\User\Bsp\delay;..\..\User\Bsp\flash;..\..\User\Bsp\iwwdg;..\..\User\Bsp\iap;..\..\User\Bsp\led;..\..\User\Hal\usart;..\..\User\Hal\delay;..\..\User\Hal\flash;..\..\User\Hal\iwwdg;..\..\User\Hal\iap;..\..\User\Hal\led;..\..\User\App\init;..\..\User\App\freertos_led;..\..\User\App\freertos_exit;..\..\User\App\freertos_iap;..\..\User\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group USER
    ../../User/: main.c stm32f4xx_it.c stm32f4xx_conf.h stm32f4xx_it.h
  group BSP
    ../../User/Bsp/led/: bsp_led.c
    ../../User/Bsp/usart/: bsp_debug_usart.c
    ../../User/Bsp/delay/: bsp_delay.c
    ../../User/Bsp/flash/: bsp_flash.c
    ../../User/Bsp/iap/: bsp_iap.c
    ../../User/Bsp/iwwdg/: bsp_iwwdg.c
    ../../User/Bsp/sys/: sys.c
  group HAL
    ../../User/Hal/led/: hal_led.c
    ../../User/Hal/usart/: hal_debug_usart.c
    ../../User/Hal/delay/: hal_delay.c
    ../../User/Hal/flash/: hal_flash.c
    ../../User/Hal/iap/: hal_iap.c
    ../../User/Hal/iwwdg/: hal_iwwdg.c
  group APP
    ../../User/App/init/: app_init.c
    ../../User/App/freertos_led/: freertos_led.c
    ../../User/App/freertos_iap/: freertos_iap.c
    ../../User/App/freertos_exit/: freertos_exit.c
  group PROTOCOL
    ../../User/protocol/: protocol.c ringbuffer.c
  group DOC
    ../../: 必读说明.txt
