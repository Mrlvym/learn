# Keil uVision project usb_stm32f407_hid_keyboard.uvprojx, settings and files
target usb_stm32f407_hid_keyboard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: usb_stm32f407_hid_keyboard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\USB_Driver\inc;..\USB_Device\Core\inc;..\USB_Device\Class\hid\inc;..\USB_Hid_KeyBoard\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c
  group USB_Driver
    ../USB_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ../USB_Device/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB_Device/Class/hid/src/: usbd_hid_core.c
  group USB_Hid_KeyBoard
    ../USB_Hid_KeyBoard/src/: usb_bsp.c usbd_desc.c usbd_hid_keyboard.c usbd_usr.c
  group README
    ../: readme.txt
